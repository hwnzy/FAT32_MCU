# Keil uVision project FAT_DEBUG.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: FAT_DEBUG +hex
  c flags: Optimize=8 SizeSpeed=1
  group FAT32
    ./: DELAY.c FAT.c LCD_12864.c SD.c MAIN.c
